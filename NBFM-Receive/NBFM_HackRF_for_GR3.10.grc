options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Amateur Radio Narrowband FM receiver
  states: {}

blocks:
- name: RF_Frequency
  id: variable
  parameters:
    value: 146e6
  states: {}
- name: SDR_samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch
    start: '-200'
    step: '1'
    stop: '0'
    value: '-10'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: 2M * (12/50) = 480k
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: RF Filter - High Cutoff
    start: '1000'
    step: '1'
    stop: SDR_samp_rate/2
    value: SDR_samp_rate/2
  states: {}
- name: variable_qtgui_range_0_1
  id: variable_qtgui_range
  parameters:
    label: Mixer Freq
    start: '-1e6'
    step: '1'
    stop: 1e6
    value: '100000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: volume*0.01
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0_1
    offset: '0'
    phase: '0'
    samp_rate: SDR_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: variable_qtgui_range_0
    decim: '1'
    gain: '1'
    samp_rate: SDR_samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: '"Before Filter"'
    bw: SDR_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Before Filter"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    alias: '"After Filter"'
    bw: SDR_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After Filter"'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: RF_Frequency
    samp_rate: SDR_samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_nbfm_rx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
