options:
  parameters:
    author: HB9HDF
    generate_options: qt_gui
    id: PlutoSDR_transmitter
    output_language: python
    title: PlutoSDR_transceiver
  states: {}

blocks:
- name: CTCSS_Freq
  id: variable
  parameters:
    value: '71.9'
  states: {}
- name: TX_freq
  id: variable
  parameters:
    value: '431050000'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '438650000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: usb_id
  id: variable
  parameters:
    value: '"usb:1.8.5"'
  states: {}
- name: variable_qtgui_range_ctcssvol
  id: variable_qtgui_range
  parameters:
    label: CTCSS Volume 0-100%
    start: '0'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: variable_qtgui_range_rxaudiovol
  id: variable_qtgui_range
  parameters:
    label: RX Audio Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_squ
  id: variable_qtgui_range
  parameters:
    label: Squelch (dB)
    start: '-200'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: variable_qtgui_range_txavol
  id: variable_qtgui_range
  parameters:
    label: Audio Source Amp 0-200%
    start: '0'
    step: '1'
    stop: '200'
    value: '80'
  states: {}
- name: variable_qtgui_range_txavol_0
  id: variable_qtgui_range
  parameters:
    label: Audio Post AGC Amp 0-200%
    start: '0'
    step: '1'
    stop: '200'
    value: '80'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0'
    max_gain: '10'
    rate: '0.01'
    reference: '0.5'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 3.5e3
    quad_rate: audio_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: CTCSS_Freq
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: variable_qtgui_range_squ
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=Headset,DEV=0
    ok_to_block: 'False'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=Headset,DEV=0
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (variable_qtgui_range_txavol)*0.01
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (variable_qtgui_range_ctcssvol)*0.01
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (variable_qtgui_range_rxaudiovol)*0.01
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: (variable_qtgui_range_txavol_0)*0.01
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.41421'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.41421'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.41421'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/benis/Desktop/voicesample.wav
    repeat: 'True'
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: TX_freq
    samplerate: samp_rate
    type: fc32
    uri: usb_id
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''hybrid'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb_id
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    min: '-0.2'
    name: '"Audio to Modulator"'
    type: float
    update_time: '0'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    min: '-0.2'
    name: '"Audio before AGC"'
    type: float
    update_time: '0'
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Audio RX Level"'
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX Output"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX Raw"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX Audio"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio to Modulator"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Audio Amplitude
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '40'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [analog_nbfm_rx_0, '0', high_pass_filter_0_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_rms_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', high_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_2_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_2_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0_2_0_0_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_0_2_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_const_vxx_0_2_0_0, '0']
- [blocks_rms_xx_0_0_0, '0', blocks_multiply_const_vxx_0_2_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0, '0']
- [high_pass_filter_0_0, '0', low_pass_filter_0_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
