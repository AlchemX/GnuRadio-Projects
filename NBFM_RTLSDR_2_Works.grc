options:
  parameters:
    author: HB9HDF
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Amateur Radio Narrowband FM receiver
  states: {}

blocks:
- name: SDR_samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: highcutoff
  id: variable_qtgui_range
  parameters:
    label: highcutoff
    start: '0'
    step: '1'
    stop: SDR_samp_rate/2
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch
    start: '-200'
    step: '1'
    stop: '0'
    value: '-10'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: volume
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '100000'
    max_dev: 5e3
    quad_rate: '100000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: highcutoff
    decim: '1'
    gain: '1'
    samp_rate: SDR_samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: '144500000'
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: SDR_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_nbfm_rx_0, '0', qtgui_sink_x_1, '0']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_1, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
